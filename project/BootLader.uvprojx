# Keil uVision project BootLader.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BootLader
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\APP;..\CPU_LIB\STM32F10X\CMSIS;..\CPU_LIB\STM32F10X\CMSIS\startup;..\CPU_LIB\STM32F10X\STM32F10x_StdPeriph_Driver\inc;..\MID\STM32F10x;..\BSP\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ../APP/: bootLoader.c
  group cpu_lib
    ../CPU_LIB/STM32F10X/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../CPU_LIB/STM32F10X/CMSIS/: core_cm3.c system_stm32f10x.c
    ../CPU_LIB/STM32F10X/CMSIS/startup/: startup_stm32f10x_hd.s
  group Mid
    ../MID/STM32F10x/: stm32f10x_mid.c
  group BSP
    ../BSP/src/: bsp_uart.c
